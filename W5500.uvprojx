# Keil uVision project W5500.uvprojx, settings and files
target Flash_Target (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: W5500 +hex
  AfterMake: fromelf.exe --bin Objects/W5500.axf --output Objects/W5500.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: EWBMMS500,__QSPIBOOT__,__ENABLE_UART_P__,__ENABLE_DMA__
  c include: .\cpu\inc;.\component\drivers\ip\inc;.\component\bsp\ms_io_board\inc;..\W5500;.\component\config\inc;.\component\drivers\Ethernet;.\component\drivers\Ethernet\W5500;.\component\drivers\Ethernet\Wiz_init;.\cpu\inc;.\config
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group eWBM
    ./component/drivers/ip/src/: ewbm_bspi.c ewbm_delay.c ewbm_dma.c ewbm_gpio.c ewbm_gpt.c ewbm_i2c.c ewbm_pmu.c ewbm_rtc.c ewbm_sdio_master.c ewbm_sdio_slave.c ewbm_spi.c ewbm_spi_arm.c ewbm_spi_ewbm.c ewbm_uart.c ewbm_wdt.c
    ./cpu/src/: ewbm_clock.c ewbm_isr.c ewbm_padmux.c system_ewbm.c startup_armcc_ARMCM0.s
    ./: main.c
  group W5500
    ./component/drivers/Ethernet/: socket.c wizchip_conf.c ping.c
    ./component/drivers/Ethernet/W5500/: w5500.c
    ./component/drivers/Ethernet/Wiz_init/: wiz_init.c
target Sram Target (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: W5500 +hex
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: EWBMMS500,__DEBUG__,__ENABLE_UART_P__,__ENABLE_DMA__
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0xa000
  memory RVCT9: RAM 0x2000a000 size 0x6000
